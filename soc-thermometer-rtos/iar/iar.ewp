# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P732F256GM32 SiliconLaboratories EFR32MG1P732F256GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32MG1P732F256GM32; HAL_CONFIG=1; __STACK_SIZE=0x800; __StackLimit=0x20000000
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..; ../.; ../platform\emdrv\tempdrv\inc; ../platform\emdrv\sleep\inc; ../platform\emdrv\common\inc; ../platform\emlib\inc; ../platform\bootloader\api; ../platform\CMSIS\Include; ../platform\Device\SiliconLabs\EFR32MG1P\Include; ../platform\emdrv\uartdrv\inc; ../platform\emdrv\gpiointerrupt\inc; ../protocol\bluetooth\ble_stack\inc\common; ../protocol\bluetooth\ble_stack\inc\soc; ../hardware\kit\common\drivers; ../hardware\kit\common\bsp; ../platform\micrium_os; ../platform\micrium_os\bsp\siliconlabs\generic\include; ../platform\micrium_os\common\include; ../platform\micrium_os\common\source\collections; ../platform\micrium_os\common\source\common; ../platform\micrium_os\common\source\kal; ../platform\micrium_os\common\source\lib; ../platform\micrium_os\common\source\logging; ../platform\micrium_os\common\source\platform_mgr; ../platform\micrium_os\common\source\rtos; ../platform\micrium_os\common\source\preprocessor; ../platform\micrium_os\common\source\ring_buf; ../platform\micrium_os\cpu\include; ../platform\micrium_os\kernel\source; ../platform\micrium_os\kernel\include; ../platform\micrium_os\ports\source\generic; ../platform\micrium_os\ports\source\iar; ../app\bluetooth\common\stack_bridge; ../platform\halconfig\inc\hal-config; ../hardware\kit\common\halconfig; ../platform\radio\rail_lib\common; ../platform\radio\rail_lib\chip\efr32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-thermometer-rtos.bin
  ILINK.IlinkOutputFile: soc-thermometer-rtos.out
  ILINK.IlinkIcfFile: ../EFR32MG1P732F256GM32.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../: main.c application_properties.c init_mcu.c init_board.c init_app.c gatt_db.c
    ../platform/emlib/src/: em_assert.c em_cmu.c em_crypto.c em_gpio.c em_i2c.c em_msc.c em_rmu.c em_rtcc.c em_usart.c em_system.c em_core.c em_emu.c em_timer.c em_cryotimer.c
    ../hardware/kit/common/bsp/: bsp_stk.c bsp_stk_leds.c
    ../platform/Device/SiliconLabs/EFR32MG1P/Source/IAR/: startup_efr32mg1p.c
    ../platform/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
    ../platform/emdrv/sleep/src/: sleep.c
    ../hardware/kit/common/drivers/: udelay.c
    ../protocol/bluetooth/ble_stack/src/soc/: rtos_bluetooth.c
    ../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_os.c bsp_cpu.c bsp_tick_rtcc.c
    ../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../platform/micrium_os/common/source/common/: common.c
    ../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
    ../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../platform/micrium_os/cpu/source/: cpu_core.c
    ../platform/micrium_os/kernel/source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
    ../platform/micrium_os/ports/source/iar/: armv7m_cpu_c.c armv7m_os_cpu_c.c armv7m_cpu_a.asm armv7m_os_cpu_a.asm
    ../platform/emdrv/tempdrv/src/: tempdrv.c
  group gattdb
    ../: gatt.xml
  group lib
    ../protocol/bluetooth/lib/EFR32MG1P/IAR/: libbluetooth.a libmbedtls.a libpsstore.a binapploader.o
    ../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
